# Keil uVision project AccessControl.uvproj, settings and files
target AccessControl (ARM-ADS)
  device: STM32F100C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PlainReader
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: .\SourceCode;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Utilities\;..\Libraries\sunid_lib\khoi\inc;..\Libraries\sunid_lib\nguyen\inc;..\Libraries\sunid_lib\thanh\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_i2c.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group Doc
    ./SourceCode/: readme.txt
  group User
    ./SourceCode/: khoitest.c main.c stm32f10x_it.c thanhtest.c demo.c
  group thanh
    ../Libraries/sunid_lib/thanh/src/: des.c pn532.c pn532_drvr.c VTimer.c crc16.c
  group khoi
    ../Libraries/sunid_lib/khoi/src/: aes.c i2c.c keyman.c TI_aes.c touchpad.c uart.c
  group SunID
    ../Utilities/: STM32sunid.c
